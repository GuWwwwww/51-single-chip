# Keil uVision project PID.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80C51BH Intel
  cpu: IRAM(0-0x7F)  IROM(0-0xFFF) CLOCK(12000000)
  output: PID +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: pid_motor.c key.c lcd.c
