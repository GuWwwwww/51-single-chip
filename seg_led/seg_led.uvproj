# Keil uVision project seg_led.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80C51BH Intel
  cpu: IRAM(0-0x7F)  IROM(0-0xFFF) CLOCK(12000000)
  output: seg_led +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: seg_led.c
