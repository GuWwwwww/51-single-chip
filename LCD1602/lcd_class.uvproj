# Keil uVision project lcd_class.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80C51BH Intel
  cpu: IRAM(0-0x7F)  IROM(0-0xFFF) CLOCK(12000000)
  output: lcd_class +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: lcd_class.c lcd.c key.c
